<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\RB-FC Board Test.ewp</path>
  </project>
  <batchBuild />
</workspace>
